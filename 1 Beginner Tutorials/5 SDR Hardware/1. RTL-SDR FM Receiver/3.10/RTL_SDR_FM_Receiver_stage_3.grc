options:
  parameters:
    generate_options: qt_gui
    id: RTL_SDR_FM_Receiver
    output_language: python
    title: RTL_SDR_FM_Receiver
  states: {}

blocks:
- name: freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,10
    label: Center Frequency
    start: 87.7e6
    step: 200e3
    stop: 107.9e6
    value: 88.5e6
  states: {}
- name: rfGain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,10
    label: RF Gain (dB)
    start: '0'
    step: '1'
    stop: '50'
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2048000'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,0,1,10
    label: Volume (dB)
    start: '-100'
    step: '0.1'
    stop: '10'
    value: '-6'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '4'
    quad_rate: 48000*4
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 10**(volume/20)
    type: float
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '32'
    interp: '3'
    type: ccc
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: freq
    gain: rfGain
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [analog_wfm_rcv_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [rational_resampler_xxx_0, '0', analog_wfm_rcv_0, '0']
- [soapy_rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [soapy_rtlsdr_source_0, '0', qtgui_time_sink_x_0, '0']
- [soapy_rtlsdr_source_0, '0', rational_resampler_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
