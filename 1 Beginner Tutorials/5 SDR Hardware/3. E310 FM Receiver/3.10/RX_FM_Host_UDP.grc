options:
  parameters:
    generate_options: qt_gui
    id: RX_FM_Host_UDP
    output_language: python
    title: Rx Fm Host Udp
  states: {}

blocks:
- name: bw
  id: variable
  parameters:
    value: 300e3
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: var_amp
  id: variable_qtgui_range
  parameters:
    label: var_amp
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.5'
  states: {}
- name: var_freq
  id: variable_qtgui_range
  parameters:
    label: var_freq
    start: '88.4'
    step: '0.01'
    stop: '107.6'
    value: '102.2'
  states: {}
- name: var_freq_MHz
  id: variable
  parameters:
    value: var_freq*1e6
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '10'
    quad_rate: samp_rate/150*12
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '16000'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.from_double(((var_freq_MHz)+300e3))
    period: '1000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: var_amp
    type: float
  states: {}
- name: network_udp_source_0
  id: network_udp_source
  parameters:
    header: '0'
    ipv6: 'False'
    notify_missed: 'False'
    port: '9997'
    src_zeros: 'True'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: bw
    fc: var_freq_MHz
    fftsize: '1024'
    grid: 'True'
    type: float
  states: {}
- name: zeromq_push_msg_sink_0
  id: zeromq_push_msg_sink
  parameters:
    address: tcp://localhost:9996
    timeout: '100'
  states: {}

connections:
- [analog_wfm_rcv_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_complex_to_mag_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_message_strobe_0, strobe, zeromq_push_msg_sink_0, in]
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [network_udp_source_0, '0', analog_wfm_rcv_0, '0']
- [network_udp_source_0, '0', blocks_complex_to_mag_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
