options:
  parameters:
    author: Barry Duggan
    generate_options: qt_gui
    id: RTTY_receive
    output_language: python
    title: RTTY_receive
  states: {}

blocks:
- name: baud
  id: variable
  parameters:
    value: 1/0.022
  states: {}
- name: center
  id: variable
  parameters:
    value: '2210'
  states: {}
- name: decim
  id: variable
  parameters:
    value: '50'
  states: {}
- name: fsk_deviation
  id: variable
  parameters:
    value: '170'
  states: {}
- name: reverse
  id: variable_qtgui_chooser
  parameters:
    label0: Normal
    label1: Reverse
    num_opts: '2'
    option0: '1'
    option1: '-1'
    type: int
    value: '1'
    widget: radio_buttons
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '11'
  states: {}
- name: sq_lvl
  id: variable_qtgui_range
  parameters:
    label: Squelch
    start: '-100'
    step: '5'
    stop: '0'
    value: '-70'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    comment: sample rate 960 Hz
    gain: samp_rate/(2*math.pi*fsk_deviation*decim)
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: sq_lvl
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: Normal/Reverse
    const: reverse
    type: float
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nTerminal Display Sink\n\"\"\"\n\n#  epy_block_0.py\n#  revised 07/07/2019\n\nimport numpy as np\nfrom gnuradio import gr\nimport pmt\n\nITA2 = [ '\\x00', 'E', '\\n', 'A', ' ', 'S', 'I', 'U', '\\r', 'D', 'R', 'J', 'N', 'F', 'C', 'K',\n            'T', 'Z', 'L', 'W', 'H', 'Y', 'P', 'Q', 'O', 'B', 'G', '\\x0e', 'M', 'X', 'V', '\\x0f',\n            '\\x00', '3', '\\n', '-', ' ', '\\x07', '8', '7', '\\r', '$', '4', '\\'', ',', '!', ':', '(',\n            '5', '\\\"', ')', '2', '#', '6', '0', '1', '9', '?', '&', '\\x0e', '.', '/', ';', '\\x0f' ]\n\n\n_samples = [ 11, 22, 33, 44, 55, 66, 77 ]\n_in_sync = 0\n_bit_count = 0\t# actually sample count from beginning of start bit\n_num_ones = 0\n_num_zeros = 0\n_byte = 0\t# this is the index into ITA2\n_in_bit = 0\n_shift = 0\noutLine = []\noutCount = 0\n\nclass my_sync_block(gr.sync_block):\n    \"\"\"\n\treads stream of 1's and 0's\n\tthere are 11 samples for each bit time\n\tsynchronizes on start bit\n\tuses majority of samples in a bit to determine validity\n\tcreates Baudot character\n\tconverts Baudot to UTF-8\n\tdisplays characters on terminal screen\n    \"\"\"\n    def __init__(self):\n        gr.sync_block.__init__(self,\n            name = \"Terminal Display Sink\",\n            in_sig = [np.byte],\n            out_sig = None)\n        self.message_port_register_out(pmt.intern('msg_out'))\n\n    def work(self, input_items, output_items):\n        global _samples\n        global _in_sync\n        global _bit_count\n        global _num_ones\n        global _num_zeros\n        global _byte\n        global _in_bit\n        global _shift\n        global outLine\n        global outCount\n\n        for ch in input_items[0]:\n            if (ch == 1):\n                _num_ones += 1       # count ones in this symbol time\n            else:\n                _num_zeros += 1      # count zeros in this symbol time\n            _bit_count += 1          # count from first start bit after syncing\n            if (_in_sync == 0):\n                if (ch == 0):\n                    _in_sync = 1\n                    _bit_count = 1\n                    _num_ones = 0\n                    _num_zeros = 1\n                    _byte = 0\n                    # print (\"sync\")\n\n            if (_bit_count in _samples) and (_in_sync == 1):    # end of this symbol time\n                if (_num_ones > 7):\n                    _in_bit = 1\n                elif (_num_zeros > 7):\n                    _in_bit = 0\n                else:\n                    _in_bit = -1\n                    _in_sync = 0    # lots of noise\n                # print (\"_in_sync\", _in_sync)\n                # print (\"_bit_count\", _bit_count)\n                # print (\"_num_ones\", _num_ones)\n                # print (\"_num_zeros\", _num_zeros)\n                _num_ones = 0\n                _num_zeros = 0\n\n                if (_in_sync == 1) and (_bit_count < 77):\n                    _byte >>= 1\n                    if (_in_bit == 1):\n                        _byte += 16\n                    # print (_byte)\n\n                if (_in_sync == 1) and (_bit_count == 77):\n                    if (_byte > 0) and (_byte < 64):\n                        _byte += _shift\n                        if ((_byte == 0x1b) or (_byte == 0x3b)):        # shift out (figs)\n                            _shift = 0x20\n                        elif ((_byte == 0x1f) or (_byte == 0x3f)):        # shift in (ltrs)\n                            _shift = 0\n                        else:\n                            if ((_byte != 2) and (_byte != 34)):\n                                outLine.append (ITA2[_byte])\n                    else:\n                        outLine.append ('*')\n                    _num_ones = 0\n                    _num_zeros = 0\n                    _in_sync = 0\n                    _bit_count = 0\n                    outCount += 1\n                    if ((outCount > 80) and (ITA2[_byte] == ' ')) or (_byte == 2) or (_byte == 34):  # LF\n                        dispLine = \"\".join (outLine)\n                        self.message_port_pub (pmt.intern('msg_out'), pmt.intern (dispLine))\n                        outLine = []\n                        outCount = 0\n\n        return len(input_items[0])\n\n"
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: center
    decim: '50'
    samp_rate: samp_rate
    taps: firdes.low_pass(1.0,samp_rate,1000,400)
    type: fcf
  states: {}
- name: note_0
  id: note
  parameters:
    note: revised 04 Apr 2024
  states: {}
- name: qtgui_eye_sink_x_0
  id: qtgui_eye_sink_x
  parameters:
    samp_per_symbol: sps
    size: '1024'
    srate: '500'
    tr_tag: ''
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    nconnections: '2'
    size: '512'
    srate: '500'
    tr_mode: qtgui.TRIG_MODE_NORM
    tr_slope: qtgui.TRIG_SLOPE_NEG
    type: float
    ymax: '1.0'
    ymin: '-1.0'
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    comment: |-
      sample rate = 500 yields
      11 samples per symbol
    decim: '960'
    interp: '500'
    taps: ''
    type: fff
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: '"rcv_demod"'
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: '"rcv_demod"'
  states: {}
- name: zeromq_push_msg_sink_0
  id: zeromq_push_msg_sink
  parameters:
    address: tcp://127.0.0.1:50252
    timeout: '100'
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', rational_resampler_xxx_0_0, '0']
- [analog_simple_squelch_cc_0, '0', analog_quadrature_demod_cf_0, '0']
- [audio_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_multiply_const_vxx_0, '0', virtual_sink_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_char_to_float_0, '0']
- [digital_binary_slicer_fb_0, '0', epy_block_0, '0']
- [epy_block_0, msg_out, zeromq_push_msg_sink_0, in]
- [freq_xlating_fir_filter_xxx_0, '0', analog_simple_squelch_cc_0, '0']
- [rational_resampler_xxx_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [rational_resampler_xxx_0_0, '0', qtgui_eye_sink_x_0, '0']
- [virtual_source_0, '0', digital_binary_slicer_fb_0, '0']
- [virtual_source_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-652-g5547874b
