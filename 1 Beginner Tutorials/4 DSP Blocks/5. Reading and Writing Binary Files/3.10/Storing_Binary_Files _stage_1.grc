options:
  parameters:
    generate_options: qt_gui
    id: Storing_Binary_Files
    output_language: python
    title: Storing_Binary_Files
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 100*10**3
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: ./binary_file.complex_float
    type: complex
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_file_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
