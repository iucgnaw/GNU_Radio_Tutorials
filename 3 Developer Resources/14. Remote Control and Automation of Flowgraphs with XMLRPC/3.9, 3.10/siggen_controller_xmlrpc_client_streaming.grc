options:
  parameters:
    author: muaddib
    generate_options: qt_gui
    id: siggen_controller_xmlrpc_client_streaming
    output_language: python
    title: SIGGEN Controller XMLRPC Client
  states: {}

blocks:
- name: freq
  id: variable_qtgui_range
  parameters:
    label: Frequency
    start: '1'
    step: '100'
    stop: samp_rate/2
    value: '1000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: xmlrpc_client_0
  id: xmlrpc_client
  parameters:
    addr: localhost
    callback: set_rmt_freq
    comment: |-
      The value used in the 'callback' field maps to a variable name in an
       XMLRPC Server or XMLRPC Server Flowgraph
      ex: 'siggen_xmlrpc_server.grc' 

      The value used in the 'variable' field is a local variable in this 
      flowgraph. Local changes to this variable will change the 
      server variable's value as well.
    port: '8000'
    variable: freq
  states: {}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:5000
    pass_tags: 'True'
    timeout: '100'
    type: complex
  states: {}

connections:
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']
- [zeromq_sub_source_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
