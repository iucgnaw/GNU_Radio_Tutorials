options:
  parameters:
    author: Frank Fu, Barry Duggan
    generate_options: qt_gui
    id: bpsk_transmit_B_Pluto
    output_language: python
    title: bpsk_transmit_B_Pluto
  states: {}

blocks:
- name: constel
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: freq
  id: variable_qtgui_entry
  parameters:
    label: Frequency
    type: int
    value: '912200000'
  states: {}
- name: fs_sel
  id: variable_qtgui_chooser
  parameters:
    label: Test mode
    label0: Calibrate
    label1: File
    num_opts: '2'
    option0: '0'
    option1: '1'
    orient: Qt.QHBoxLayout
    type: int
    value: '1'
    widget: radio_buttons
  states: {}
- name: hdr
  id: variable
  parameters:
    value: digital.header_format_default(digital.packet_utils.default_access_code, 0)
  states: {}
- name: payload_size
  id: variable
  parameters:
    value: '64'
  states: {}
- name: postamble_size
  id: variable
  parameters:
    value: '64'
  states: {}
- name: preamble_size
  id: variable
  parameters:
    value: '64'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: tx_atten
  id: variable_qtgui_range
  parameters:
    comment: 'NOTE: attenuation!'
    label: Tx Attenuation
    start: '0'
    step: '1'
    stop: '89'
    value: '30'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: bpsk_transmit.txt
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: bpsk_transmit.txt
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.5'
    type: complex
  states: {}
- name: blocks_selector_0_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: fs_sel
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: payload_size
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0_0_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: preamble_size
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0_0_0_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: postamble_size
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '4'
    type: byte
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    comment: Preamble
    repeat: 'True'
    type: byte
    vector: '[0xc0, 0xaf]'
  states: {}
- name: blocks_vector_source_x_0_0
  id: blocks_vector_source_x
  parameters:
    comment: Postamble
    repeat: 'True'
    type: byte
    vector: '[0xc0, 0xaf]'
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: constel
    differential: 'True'
    excess_bw: '0.35'
    samples_per_symbol: sps
  states: {}
- name: digital_crc32_bb_0
  id: digital_crc32_bb
  parameters:
    check: 'False'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: digital_protocol_formatter_bb_0
  id: digital_protocol_formatter_bb
  parameters:
    format: hdr
    len_tag_key: packet_len
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: tx_atten
    bandwidth: '200000'
    buffer_size: '2048'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: freq
    samplerate: samp_rate
    type: fc32
    uri: ip:pluto.local
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Transmit data"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      with open("bpsk_transmit.txt", "w") as f:
          i = 0
          while (i < 24):
              payload = chr(85) * 64
              f.write(payload)
              i += 1
          for val in range(0x30, 0x3A):
              payload = chr(val) * 64
              f.write(payload)
          i = 0
          while (i < 12):
              payload = chr(42) * 64
              f.write(payload)
              i += 1
    comment: Create transmit file
    section: init_before_blocks
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: header
  states: {}
- name: virtual_sink_2_0
  id: virtual_sink
  parameters:
    stream_id: payload
  states: {}
- name: virtual_source_5
  id: virtual_source
  parameters:
    stream_id: header
  states: {}
- name: virtual_source_6
  id: virtual_source
  parameters:
    stream_id: payload
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_selector_0_0, '0']
- [blocks_file_source_0_0, '0', blocks_selector_0_0, '1']
- [blocks_multiply_const_vxx_0, '0', iio_pluto_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_selector_0_0, '0', blocks_stream_to_tagged_stream_0_0_0, '0']
- [blocks_stream_to_tagged_stream_0_0_0, '0', digital_crc32_bb_0, '0']
- [blocks_stream_to_tagged_stream_0_0_0_0, '0', blocks_tagged_stream_mux_0, '0']
- [blocks_stream_to_tagged_stream_0_0_0_0_0, '0', blocks_tagged_stream_mux_0, '3']
- [blocks_tagged_stream_mux_0, '0', digital_constellation_modulator_0, '0']
- [blocks_vector_source_x_0, '0', blocks_stream_to_tagged_stream_0_0_0_0, '0']
- [blocks_vector_source_x_0_0, '0', blocks_stream_to_tagged_stream_0_0_0_0_0, '0']
- [digital_constellation_modulator_0, '0', blocks_multiply_const_vxx_0, '0']
- [digital_crc32_bb_0, '0', digital_protocol_formatter_bb_0, '0']
- [digital_crc32_bb_0, '0', virtual_sink_2_0, '0']
- [digital_protocol_formatter_bb_0, '0', virtual_sink_0_0, '0']
- [virtual_source_5, '0', blocks_tagged_stream_mux_0, '1']
- [virtual_source_6, '0', blocks_tagged_stream_mux_0, '2']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
